# Keil uVision project ZKXL_YYKSLQ_CPU.uvprojx, settings and files
target V0100 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YYKSLQ_DISCHARGE_TEST_V0100_20170713 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,ZL_RP551_MAIN_F
  c include: ..\lib\cJSON;..\lib\common;..\lib\STM32F10x_StdPeriph_Driver\inc;..\bsp;..\bsp\board;..\bsp\driver\eeprom;..\bsp\driver\m24sr;..\bsp\driver\nrf51822;..\bsp\driver\rc500;..\bsp\driver\si24r2e;..\user;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group START
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group LIB/STDLIB
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LIB/CJSON
    ../lib/cJSON/: cJSON.c cJSON_Utils.c
  group LIB/COMMON
    ../lib/common/: app_timer.c ringbuffer.c whitelist.c
  group BSP/BOARD
    ../bsp/board/: baord.c gpio.c init.c
  group BSP/DRIVER
    ../bsp/driver/eeprom/: eeprom.c
    ../bsp/driver/m24sr/: m24sr_cmd.c
    ../bsp/driver/nrf51822/: nrf.c
    ../bsp/driver/rc500/: mfrc500.c mfrc500_hw.c mfrc500_ios14443.c
    ../bsp/driver/si24r2e/: si24r2e.c yyk_protocol.c
  group BSP
    ../bsp/: version.c
  group USER
    ../user/: main.c stm32f10x_it.c task_find_card.c task_serial_cmd.c task_show_message.c task_spi_message.c
software components: CMSIS:CORE 4.3.0
